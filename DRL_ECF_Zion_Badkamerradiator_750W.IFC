Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: ENSAMBLAJE 750W TOALLERO ZINNIA.IFC
Time: 2023-01-17T12:09:46
Written by: SwIFC
Made in: SolidWorks 2014

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m
